<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\3-1_led_shift.ewp</path>
    </project>
    <batchBuild />
</workspace>
