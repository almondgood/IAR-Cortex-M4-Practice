<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\kcci_m4_project.ewp</path>
    </project>
    <batchBuild />
</workspace>
