<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\4-1_key.ewp</path>
    </project>
    <batchBuild />
</workspace>
