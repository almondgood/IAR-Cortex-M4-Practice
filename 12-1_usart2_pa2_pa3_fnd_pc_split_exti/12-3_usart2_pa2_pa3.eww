<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\12-3_usart2_pa2_pa3.ewp</path>
    </project>
    <batchBuild />
</workspace>
